<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 24 16:32:10 2026</timestamp>
			<uuid>{488dfaae-07fd-47c2-80c7-a1d3d41bb281}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/top/students/UNGRAD/ECE/jadenf/home/ECE571/TSMC_Cadence/Inverter1/12BitBCD/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/top/students/UNGRAD/ECE/jadenf/home/ECE571/TSMC_Cadence/Inverter1/12BitBCD/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/top/students/UNGRAD/ECE/jadenf/home/simulation/Inverter1/12BitBCD/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Inverter1/12BitBCD/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
