<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 26 16:02:12 2026</timestamp>
			<uuid>{afa3d669-9c31-445b-bccc-3bee2149042c}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/top/students/UNGRAD/ECE/jadenf/home/ECE571/TSMC_Cadence/Inverter1/12BitBCDFull_tb/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/top/students/UNGRAD/ECE/jadenf/home/ECE571/TSMC_Cadence/Inverter1/12BitBCDFull_tb/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/top/students/UNGRAD/ECE/jadenf/home/simulation/Inverter1/12BitBCDFull_tb/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Inverter1/12BitBCDFull_tb/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
